# Postinstall intercepts need these native tools in the image sysroot
DEPENDS += "desktop-file-utils-native shared-mime-info-native"
