RDEPENDS:pulseaudio-server:remove:hoki = " pulseaudio-modules-droid-jb2q "

# pactl bash-completion script requires bash
RDEPENDS:pulseaudio-bash-completion += "bash"
