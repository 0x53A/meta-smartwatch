# Enable Opus codec support (libopus + opusdec/opusenc elements)
PACKAGECONFIG:append = " opus"
