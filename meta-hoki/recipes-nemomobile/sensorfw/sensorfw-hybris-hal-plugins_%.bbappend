FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0007-Add-SpO2-sensor-with-hybris-adaptor.patch \
            file://0008-Add-vendor-health-sensors.patch \
            file://0009-Fix-compass-degrees-use-qreal-and-fmod-instead-of-int.patch"
