# NFC on hoki uses the mainline kernel NFC stack (nxp-nci driver) + neard.
# nfcd is fully removed from IMAGE_INSTALL in hoki.conf.
