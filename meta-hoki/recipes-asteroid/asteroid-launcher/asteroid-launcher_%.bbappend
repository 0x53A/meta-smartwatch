# Upstream updated copyright year without updating the recipe checksum
LIC_FILES_CHKSUM = "file://src/qml/MainScreen.qml;beginline=1;endline=29;md5=dc9980ea8441655e2d7b323a30b7172d"
