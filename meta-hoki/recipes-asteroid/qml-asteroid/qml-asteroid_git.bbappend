# Pin to commit before FindMlite5.cmake removal (69563ac).
# Upstream qml-asteroid removed FindMlite5.cmake but asteroid-launcher
# still uses find_package(Mlite5). Unpin once launcher is updated upstream.
SRCREV = "eaa86613d635bd3e8a39d17970ecb338410497e0"
