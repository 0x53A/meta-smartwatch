# Pin to commit before broken Weblate translation XML
SRCREV = "09da87087b5b7a7898b67f424c1fd2b4da7d464a"
