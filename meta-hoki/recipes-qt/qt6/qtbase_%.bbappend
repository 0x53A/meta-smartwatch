FILESEXTRAPATHS:prepend := "${THISDIR}/qtbase:"
SRC_URI += "file://0003-evdevmouse-Add-wheelscale-parameter-for-hi-res-rotar.patch"
