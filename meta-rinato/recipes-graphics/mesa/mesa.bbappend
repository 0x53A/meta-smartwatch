PACKAGECONFIG:append:rinato = " lima"
